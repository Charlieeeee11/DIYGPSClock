# Keil uVision project GPSCalibrateClock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408S STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: GPSCalibrateClock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c ADC.c
